# Keil uVision project Template.uvprojx, settings and files
target zet6 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zet6 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_BOOT=0,DEBUG_SHELL=0
  c include: ..\sys\systick;..\sys\sys;..\sys\;..\bsp;..\lib;..\lib\STM32F10x_FWLib\inc;..\app\WiFiToCloud;..\app;..\RFID;..\drivers\LoRa;..\Buzzer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c hal_core.c hal_core.h hal_iic.c hardwareVariables.h
    ./: hardwareVariables.c
  group app/cloud
    ../app/WiFiToCloud/: HAL_WiFiToCloud.c WiFiToCloud.c app_cloud.c app_cloud.h CloudReference.h
  group usart and timer
    ../bsp/: usart3.c timer.c bsp_uart4.c bsp_uart4.h bsp_rtc.c bsp_timer3.c usart2.c usart2.h usart.c
  group lib/stm32lib
    ../lib/: stm32f10x_it.c core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../lib/STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c
  group Lora
    ../drivers/LoRa/: lora_app.c lora_ui.c
  group Sys
    ../sys/systick/: systick.c
    ../sys/sys/: sys.c
    ../sys/: delay.c
  group RFID
    ../RFID/: rfid.c
  group Buzzer
    ../Buzzer/: buzzer.c
